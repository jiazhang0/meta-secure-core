include linux-yocto-integrity.inc
