include linux-yocto-tpm2.inc
