RDEPENDS_${PN} += "lvm2"
RRECOMMENDS_${PN}_append_class-target = " lvm2-udevrules"
