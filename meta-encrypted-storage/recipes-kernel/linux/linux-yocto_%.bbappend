include linux-yocto-encrypted-storage.inc
