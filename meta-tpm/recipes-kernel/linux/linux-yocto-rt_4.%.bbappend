include linux-yocto-tpm.inc
